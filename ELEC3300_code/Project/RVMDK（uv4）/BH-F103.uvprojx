# Keil uVision project BH-F103.uvprojx, settings and files
target 摄像头—OV7725 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OV7725 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\FATFS\option;..\..\User\FATFS;..\..\Mass_Storage\inc;..\..\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/ov7725/: bsp_ov7725.c
    ../../User/sccb/: bsp_sccb.c
    ../../User/lcd/: bsp_ili9341_lcd.c bsp_lcd.c bsp_xpt2046_lcd.c
    ../../User/font/: fonts.c
    ../../User/led/: bsp_led.c
    ../../User/usart/: bsp_usart.c bsp_usart_blt.c
    ../../User/Key/: bsp_key.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/sdio/: bsp_sdio_sdcard.c
    ../../User/bmp/: bsp_bmp.c
    ../../User/57StepMotor/: bsp_TB6600_TIM.c
    ../../User/Group50/: Group50.c
    ../../User/SG90/: bsp_GeneralTIM.c
    ../../User/tjpgd/src/: jpgPort.c tjpgd.c
    ../../User/hc05/: bsp_hc05.c
  group Fatfs
    ../../User/FATFS/: diskio.c ff.c
    ../../User/FATFS/option/: ccsbcs.c syscall.c
  group DOC
    ../../Doc/: readme.txt
  group Mass_Storage
    ../../Mass_Storage/src/: fsmc_nand.c hw_config.c mass_mal.c memory.c nand_if.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group Driver
    ../../STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
